EXTRA_OECONF_append  = " --with-ccsp-arch=arm"
